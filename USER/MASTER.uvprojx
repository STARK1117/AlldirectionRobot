# Keil uVision project MASTER.uvprojx, settings and files
target MASTER (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MASTER +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\INIT\LED;..\INIT\CAN;..\INIT\USART3;..\FWLIB\inc;..\CORE;..\INIT\DRIVER;..\TF;..\INIT\QUEUE;..\INIT\TIMER;..\Receive_Handle;..\INIT\PID
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group INIT
    ../INIT/LED/: led.c
    ../INIT/CAN/: can.c
    ../INIT/USART3/: usart3.c
    ../INIT/DRIVER/: driver.c
    ../INIT/QUEUE/: queue.c
    ../INIT/TIMER/: timer.c
    ../INIT/PID/: angle_pid.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group TF
    ../TF/: transform.c
  group Receive_Handle
    ../Receive_Handle/: Receive_Handle.c
